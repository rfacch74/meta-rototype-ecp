FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_mx8mq = " \
		file://0001-fixed-dtb-for-imx8mq-ecp.patch \
"

